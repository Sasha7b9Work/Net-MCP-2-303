# Keil uVision project MS-1.uvprojx, settings and files
target Debug (6210000::V6.21::.\ARMCLANG539)
  device: STM32F303CBTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.2.2
  cpu: IRAM(0x20000000,0x0000A000) IRAM2(0x10000000,0x00002000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MS-1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=8 v6Lto=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F303xC
  c include: .\src;.\src\Hardware\HAL;.\src\Hardware\CDC;..\common\STM32Cube_F3\Drivers\STM32F3xx_HAL_Driver\Inc;..\common\STM32Cube_F3\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\common\STM32Cube_F3\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\common\STM32Cube_F3\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\common\STM32Cube_F3\Drivers\CMSIS\Core\Include;..\common\STM32Cube_F3\Drivers\CMSIS\Device\ST\STM32F3xx\Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  scatter file: .\MS-1.sct
  group STM32F3
    ../common/STM32Cube_F3/Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_cortex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_pcd.c stm32f3xx_hal_rcc.c stm32f3xx_hal_spi.c stm32f3xx_hal_uart.c stm32f3xx_hal_dma.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_adc.c stm32f3xx_hal_i2c.c stm32f3xx_hal_pcd_ex.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_rtc.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_rtc_ex.c stm32f3xx_ll_usb.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_wwdg.c stm32f3xx_hal_iwdg.c
  group src
    ./src/: main.cpp defines.h Device.cpp Device.h description.txt opt.h
  group Display
    ./src/Display/: Colors.cpp Colors.h Display.cpp Display.h Zones.cpp Zones.h StartScreen.cpp StartScreen.h
  group Display/Font
    ./src/Display/Font/: Font.cpp Font.h font8.inc
  group Hardware
    ./src/Hardware/: Timer.cpp Timer.h InterCom.cpp InterCom.h Keyboard.cpp Keyboard.h Beeper.cpp Beeper.h EnergySwitch.cpp EnergySwitch.h
  group Hardware/CMSIS
    ./src/Hardware/CMSIS/: startup_stm32f303xc.s system_stm32f3xx.c
  group Hardware/CDC
    ./src/Hardware/CDC/: usbd_conf.h usbd_desc.h usbd_conf.c usbd_desc.c CDC.h CDC.cpp
    ../common/STM32Cube_F3/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../common/STM32Cube_F3/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Hardware/HAL
    ./src/Hardware/HAL/: HAL.cpp HAL.h HAL_I2C.cpp HAL_IT.cpp HAL_RTC.cpp HAL_ROM.cpp HAL_ADC.cpp HAL_PINS.cpp HAL_PINS.h HAL_SPI1.cpp HAL_USART1.cpp HAL_USART2.cpp HAL_IWDG.cpp stm32f3xx_hal_conf.h
  group Menu
    ./src/Menu/: Menu.cpp Menu.h MenuItems.cpp MenuItems.h
  group Menu/Pages
    ./src/Menu/Pages/: PageDisplay.cpp PageHC12.cpp Pages.cpp Pages.h PageSystem.cpp PageMeasures.cpp PageDataBase.cpp PageDataBaseBrowsing.cpp PageDataBaseSettings.cpp
  group Modules/BME280
    ./src/Modules/BME280/: BME280.cpp BME280.h bme280_defs.h bme280_driver.c bme280_driver.h
  group Modules/CG-Anem
    ./src/Modules/CG-Anem/: CG-Anem.cpp CG-Anem.h
  group Modules/GY511
    ./src/Modules/GY511/: GY511.cpp GY511.h
  group Modules/HC12
    ./src/Modules/HC12/: HC12.cpp HC12.h
  group Modules/NEO-M8N
    ./src/Modules/NEO-M8N/: NEO-M8N.cpp NEO-M8N.h
  group Modules/ST7735
    ./src/Modules/ST7735/: ST7735.cpp ST7735.h
  group Modules/W25Q80DV
    ./src/Modules/W25Q80DV/: W25Q80DV.cpp W25Q80DV.h
  group SCPI
    ./src/SCPI/: SCPI.cpp SCPI.h
  group Settings
    ./src/Settings/: Settings.cpp Settings.h
  group Storage
    ./src/Storage/: Storage.cpp Storage.h MemoryStorage.cpp MemoryStorage.h Measures.cpp Measures.h
  group Utils
    ./src/Utils/: Math.h Buffer.h Math.cpp Values.cpp Values.h Debug.cpp Debug.h RingBuffer.h Log.cpp Log.h
  group Utils/Text
    ./src/Utils/Text/: String.cpp String.h Text.cpp Text.h
  group Hardware/HAL/I2C
    ./src/Hardware/HAL/I2C/: readme.md sw_i2c.cpp sw_i2c.h sw_i2c_port_stm32.cpp
  group Tests
    ./src/Tests/: Tests.cpp Tests.h
target Release (6210000::V6.21::.\ARMCLANG539)
  device: STM32F303CBTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.2.2
  cpu: as above
  output: MS-1 +hex
  c flags: Optim=7 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=8 v6Lto=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F303xC
  c include: .\src;.\src\Hardware\HAL;.\src\Hardware\CDC;..\common\STM32Cube_F3\Drivers\STM32F3xx_HAL_Driver\Inc;..\common\STM32Cube_F3\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\common\STM32Cube_F3\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\common\STM32Cube_F3\Drivers\CMSIS\Device\ST\STM32F3xx\Include;..\common\STM32Cube_F3\Drivers\CMSIS\Core\Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
